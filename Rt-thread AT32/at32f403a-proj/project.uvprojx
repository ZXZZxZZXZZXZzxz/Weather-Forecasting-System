# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARM_LIBC, AT32F403AVGT7, USE_STDPERIPH_DRIVER
  c include: applications;.;..\Libraries\AT32_Std_Driver\CMSIS\AT32\AT32F4xx\inc;..\Libraries\AT32_Std_Driver\CMSIS;..\Libraries\AT32_Std_Driver\AT32F4xx_StdPeriph_Driver\inc;board;board\msp;..\Libraries\rt_drivers;.;..\..\..\include;.\Source\Dev;.\packages;.\Source\WIFI;.\Source\HMI;.\applications;.\Source\malloc;..\Rt-thread\components\drivers\include;..\Rt-thread\libcpu\arm\common;..\Rt-thread\libcpu\arm\cortex-m4;..\Rt-thread\components\dfs\include;..\Rt-thread\components\dfs\filesystems\elmfat;..\Rt-thread\components\dfs\filesystems\devfs;..\Rt-thread\components\finsh;..\Rt-thread\src;..\Rt-thread\components\libc\compilers\armlibc;..\Rt-thread\components\libc\compilers\common;..\Rt-thread\components\libc\compilers\common\sys;..\Rt-thread\include;..\Rt-thread\components\drivers\include\drivers;.\packages\netutils-v1.1.0\ntp;..\Rt-thread\components\net\netdev\include\arpa;..\Rt-thread\components\net\netdev\include;..\Rt-thread\components\net\sal_socket\include\socket\sys_socket\sys;..\Rt-thread\components\net\sal_socket\include;..\Rt-thread\components\net\sal_socket\include\socket
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./applications/: config.h
    ./: rtconfig.h
  group AT32_Lib
    ../Libraries/AT32_Std_Driver/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_adc.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_sdio.c at32f4xx_acc.c at32f4xx_bkp.c at32f4xx_rtc.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_xmc.c at32f4xx_comp.c at32f4xx_dac.c misc.c
  group cpu
    ../Rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../Rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../Rt-thread/components/drivers/misc/: pin.c
    ../Rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../Rt-thread/components/drivers/serial/: serial.c
    ../Rt-thread/components/drivers/rtc/: rtc.c
    ../Rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/: board.c
    board/msp/: at32_msp.c system_at32f4xx.c
    ../Libraries/AT32_Std_Driver/CMSIS/AT32/AT32F4xx/src/mdk/: startup_at32f403avgt7.s
    ../Libraries/rt_drivers/: drv_gpio.c drv_usart.c drv_rtc.c drv_wdt.c
  group finsh
    ../Rt-thread/components/finsh/: cmd.c msh.c msh_file.c shell.c
  group Kernel
    ../Rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group ff
    ../Rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../Rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group libc
    ../Rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../Rt-thread/components/libc/compilers/common/: time.c
  group packages
    ./packages/: cJSON.c cJSON_port.c cJSON_util.c
  group Dev
    ./Source/Dev/: Usart.c Task.c system.c SysTick.c HMIrtc.c
  group WIFI
    ./Source/WIFI/: BspEsp8266.c WifiSet.c WeatherInfo.c NtpExample.c
  group HMI
    ./Source/HMI/: HMI.c
  group malloc
    ./Source/malloc/: malloc.c utf8togbk.c GbkToUtf_8.c
